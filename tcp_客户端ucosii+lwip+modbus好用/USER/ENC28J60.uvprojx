# Keil uVision project ENC28J60.uvprojx, settings and files
target ENC28J60 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF24L01 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\MALLOC;..\CORE;..\USMART;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\SRAM;..\HARDWARE\ENC28J60;..\UCOSII\PORT;..\UCOSII\CORE;..\UCOSII\CONFIG;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\HARDWARE\WDG;..\HARDWARE\MASTER;..\LWIP\lwip_app\udp_demo;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/MASTER/: master.c
    ../HARDWARE/ADC/: adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../LWIP/lwip_app/udp_demo/: udp_demo.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
